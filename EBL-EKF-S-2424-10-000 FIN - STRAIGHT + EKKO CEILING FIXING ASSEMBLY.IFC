Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Fin - Straight\EBL-EKF-S-2424-10-000 FIN - STRAIGHT + EKKO CEILING FIXING ASSEMBLY.IFC
Time: 2024-12-18T11:40:01+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 81.4496724892434543; Volume Measure: 0.0814496724892440; Area Measure: 15.2744204805314308

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 81.4496724892434543; Volume Measure: 0.0814496724892440; Area Measure: 15.2744204805314308

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 81.4496724892434543; Volume Measure: 0.0814496724892440; Area Measure: 15.2744204805314308

# IfcBuildingElementProxy (196)
In: default BuildingStorey
Name
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + EKKO CEILING FIXING ASSEMBLY | PSet_Mass_Property - Mass Measure: 81.4496724892434543; Volume Measure: 0.0814496724892440; Area Measure: 15.2744204805314308
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY
13 x ACF SUSRAIL - PRIMARY - WIDE
13 x EBL-EKF-S-2424-10-000 FIN - STRAIGHT
PRIMARY TO SECONDARY CONNECTOR
ACF SUSRAIL - PRIMARY SECONDARY
F000264 P50 SUSPENSION FITTING.SLDPRT
20 x F000264 P50 Clutch Fitting
20 x F000264 P50 Tensile Steel Wire 2m
20 x F000264 P50 Top Threaded Insert
20 x F000264 P50 M5 Threaded Bolt
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-1
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-2
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-3
PRIMARY TO SECONDARY CONNECTOR-1
PRIMARY TO SECONDARY CONNECTOR-2
PRIMARY TO SECONDARY CONNECTOR-3
PRIMARY TO SECONDARY CONNECTOR-4
PRIMARY TO SECONDARY CONNECTOR-5
PRIMARY TO SECONDARY CONNECTOR-6
PRIMARY TO SECONDARY CONNECTOR-7
PRIMARY TO SECONDARY CONNECTOR-8
PRIMARY TO SECONDARY CONNECTOR-9
PRIMARY TO SECONDARY CONNECTOR-10
PRIMARY TO SECONDARY CONNECTOR-11
PRIMARY TO SECONDARY CONNECTOR-12
PRIMARY TO SECONDARY CONNECTOR-13
PRIMARY TO SECONDARY CONNECTOR-14
PRIMARY TO SECONDARY CONNECTOR-15
PRIMARY TO SECONDARY CONNECTOR-16
PRIMARY TO SECONDARY CONNECTOR-17
PRIMARY TO SECONDARY CONNECTOR-18
PRIMARY TO SECONDARY CONNECTOR-19
PRIMARY TO SECONDARY CONNECTOR-20
PRIMARY TO SECONDARY CONNECTOR-21
PRIMARY TO SECONDARY CONNECTOR-22
PRIMARY TO SECONDARY CONNECTOR-23
PRIMARY TO SECONDARY CONNECTOR-24
PRIMARY TO SECONDARY CONNECTOR-25
PRIMARY TO SECONDARY CONNECTOR-26
PRIMARY TO SECONDARY CONNECTOR-27
PRIMARY TO SECONDARY CONNECTOR-28
F000264 P50 SUSPENSION FITTING.SLDPRT-1
F000264 P50 SUSPENSION FITTING.SLDPRT-2
F000264 P50 SUSPENSION FITTING.SLDPRT-3
F000264 P50 SUSPENSION FITTING.SLDPRT-4
F000264 P50 SUSPENSION FITTING.SLDPRT-5
F000264 P50 SUSPENSION FITTING.SLDPRT-6
F000264 P50 SUSPENSION FITTING.SLDPRT-7
F000264 P50 SUSPENSION FITTING.SLDPRT-8
ACF SUSRAIL - PRIMARY SECONDARY-1
ACF SUSRAIL - PRIMARY SECONDARY-2
F000264 P50 SUSPENSION FITTING.SLDPRT-9
F000264 P50 SUSPENSION FITTING.SLDPRT-10
F000264 P50 SUSPENSION FITTING.SLDPRT-11
F000264 P50 SUSPENSION FITTING.SLDPRT-12
F000264 P50 SUSPENSION FITTING.SLDPRT-13
F000264 P50 SUSPENSION FITTING.SLDPRT-14
F000264 P50 SUSPENSION FITTING.SLDPRT-15
F000264 P50 SUSPENSION FITTING.SLDPRT-16
ACF SUSRAIL - PRIMARY SECONDARY-3
F000264 P50 SUSPENSION FITTING.SLDPRT-17
F000264 P50 SUSPENSION FITTING.SLDPRT-18
F000264 P50 SUSPENSION FITTING.SLDPRT-19
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-4
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-5
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-6
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-7
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-8
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-9
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-10
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-11
EBL-EKF-S-2424-10-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-12
PRIMARY TO SECONDARY CONNECTOR-29
PRIMARY TO SECONDARY CONNECTOR-30
PRIMARY TO SECONDARY CONNECTOR-31
PRIMARY TO SECONDARY CONNECTOR-32
PRIMARY TO SECONDARY CONNECTOR-33
PRIMARY TO SECONDARY CONNECTOR-34
PRIMARY TO SECONDARY CONNECTOR-35
PRIMARY TO SECONDARY CONNECTOR-36
PRIMARY TO SECONDARY CONNECTOR-37
PRIMARY TO SECONDARY CONNECTOR-38
PRIMARY TO SECONDARY CONNECTOR-39
PRIMARY TO SECONDARY CONNECTOR-40
PRIMARY TO SECONDARY CONNECTOR-41
PRIMARY TO SECONDARY CONNECTOR-42
PRIMARY TO SECONDARY CONNECTOR-43
PRIMARY TO SECONDARY CONNECTOR-44
PRIMARY TO SECONDARY CONNECTOR-45
PRIMARY TO SECONDARY CONNECTOR-46
PRIMARY TO SECONDARY CONNECTOR-47
PRIMARY TO SECONDARY CONNECTOR-48
PRIMARY TO SECONDARY CONNECTOR-49
PRIMARY TO SECONDARY CONNECTOR-50
PRIMARY TO SECONDARY CONNECTOR-51
