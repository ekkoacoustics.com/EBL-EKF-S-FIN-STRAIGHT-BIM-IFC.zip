Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Fin - Straight\EBL-EKF-S-2424-20-000 FIN - STRAIGHT + EKKO CEILING FIXING ASSEMBLY.IFC
Time: 2024-12-18T11:41:56+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 583.9967224797001109; Volume Measure: 0.5839967224796989; Area Measure: 75.1663702772964513

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 583.9967224797001109; Volume Measure: 0.5839967224796989; Area Measure: 75.1663702772964513

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 583.9967224797001109; Volume Measure: 0.5839967224796989; Area Measure: 75.1663702772964513

# IfcBuildingElementProxy (468)
In: default BuildingStorey
Name
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + EKKO CEILING FIXING ASSEMBLY | PSet_Mass_Property - Mass Measure: 583.9967224797001109; Volume Measure: 0.5839967224796989; Area Measure: 75.1663702772964513
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY
49 x EBL-EKF-S-2424-20-000 FIN - STRAIGHT
49 x ACF SUSRAIL - PRIMARY - WIDE
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-1
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-2
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-3
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-4
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-5
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-6
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-7
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-8
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-9
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-10
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-11
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-12
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-13
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-14
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-15
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-16
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-17
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-18
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-19
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-20
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-21
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-22
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-23
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-24
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-25
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-26
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-27
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-28
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-29
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-30
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-31
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-32
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-33
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-34
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-35
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-36
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-37
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-38
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-39
ACF SUSRAIL - PRIMARY SECONDARY
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-40
F000264 P50 SUSPENSION FITTING.SLDPRT
24 x F000264 P50 Clutch Fitting
24 x F000264 P50 Tensile Steel Wire 2m
24 x F000264 P50 Top Threaded Insert
24 x F000264 P50 M5 Threaded Bolt
PRIMARY TO SECONDARY CONNECTOR
PRIMARY TO SECONDARY CONNECTOR-1
PRIMARY TO SECONDARY CONNECTOR-2
PRIMARY TO SECONDARY CONNECTOR-3
PRIMARY TO SECONDARY CONNECTOR-4
PRIMARY TO SECONDARY CONNECTOR-5
PRIMARY TO SECONDARY CONNECTOR-6
PRIMARY TO SECONDARY CONNECTOR-7
PRIMARY TO SECONDARY CONNECTOR-8
PRIMARY TO SECONDARY CONNECTOR-9
PRIMARY TO SECONDARY CONNECTOR-10
PRIMARY TO SECONDARY CONNECTOR-11
PRIMARY TO SECONDARY CONNECTOR-12
PRIMARY TO SECONDARY CONNECTOR-13
PRIMARY TO SECONDARY CONNECTOR-14
PRIMARY TO SECONDARY CONNECTOR-15
PRIMARY TO SECONDARY CONNECTOR-16
PRIMARY TO SECONDARY CONNECTOR-17
PRIMARY TO SECONDARY CONNECTOR-18
PRIMARY TO SECONDARY CONNECTOR-19
PRIMARY TO SECONDARY CONNECTOR-20
PRIMARY TO SECONDARY CONNECTOR-21
PRIMARY TO SECONDARY CONNECTOR-22
PRIMARY TO SECONDARY CONNECTOR-23
PRIMARY TO SECONDARY CONNECTOR-24
PRIMARY TO SECONDARY CONNECTOR-25
PRIMARY TO SECONDARY CONNECTOR-26
PRIMARY TO SECONDARY CONNECTOR-27
PRIMARY TO SECONDARY CONNECTOR-28
PRIMARY TO SECONDARY CONNECTOR-29
PRIMARY TO SECONDARY CONNECTOR-30
PRIMARY TO SECONDARY CONNECTOR-31
PRIMARY TO SECONDARY CONNECTOR-32
PRIMARY TO SECONDARY CONNECTOR-33
PRIMARY TO SECONDARY CONNECTOR-34
PRIMARY TO SECONDARY CONNECTOR-35
PRIMARY TO SECONDARY CONNECTOR-36
PRIMARY TO SECONDARY CONNECTOR-37
PRIMARY TO SECONDARY CONNECTOR-38
PRIMARY TO SECONDARY CONNECTOR-39
PRIMARY TO SECONDARY CONNECTOR-40
PRIMARY TO SECONDARY CONNECTOR-41
PRIMARY TO SECONDARY CONNECTOR-42
PRIMARY TO SECONDARY CONNECTOR-43
PRIMARY TO SECONDARY CONNECTOR-44
PRIMARY TO SECONDARY CONNECTOR-45
PRIMARY TO SECONDARY CONNECTOR-46
PRIMARY TO SECONDARY CONNECTOR-47
PRIMARY TO SECONDARY CONNECTOR-48
PRIMARY TO SECONDARY CONNECTOR-49
PRIMARY TO SECONDARY CONNECTOR-50
PRIMARY TO SECONDARY CONNECTOR-51
PRIMARY TO SECONDARY CONNECTOR-52
PRIMARY TO SECONDARY CONNECTOR-53
PRIMARY TO SECONDARY CONNECTOR-54
PRIMARY TO SECONDARY CONNECTOR-55
PRIMARY TO SECONDARY CONNECTOR-56
PRIMARY TO SECONDARY CONNECTOR-57
PRIMARY TO SECONDARY CONNECTOR-58
PRIMARY TO SECONDARY CONNECTOR-59
PRIMARY TO SECONDARY CONNECTOR-60
PRIMARY TO SECONDARY CONNECTOR-61
PRIMARY TO SECONDARY CONNECTOR-62
PRIMARY TO SECONDARY CONNECTOR-63
PRIMARY TO SECONDARY CONNECTOR-64
PRIMARY TO SECONDARY CONNECTOR-65
PRIMARY TO SECONDARY CONNECTOR-66
PRIMARY TO SECONDARY CONNECTOR-67
PRIMARY TO SECONDARY CONNECTOR-68
PRIMARY TO SECONDARY CONNECTOR-69
PRIMARY TO SECONDARY CONNECTOR-70
PRIMARY TO SECONDARY CONNECTOR-71
PRIMARY TO SECONDARY CONNECTOR-72
PRIMARY TO SECONDARY CONNECTOR-73
PRIMARY TO SECONDARY CONNECTOR-74
PRIMARY TO SECONDARY CONNECTOR-75
PRIMARY TO SECONDARY CONNECTOR-76
PRIMARY TO SECONDARY CONNECTOR-77
PRIMARY TO SECONDARY CONNECTOR-78
PRIMARY TO SECONDARY CONNECTOR-79
PRIMARY TO SECONDARY CONNECTOR-80
PRIMARY TO SECONDARY CONNECTOR-81
PRIMARY TO SECONDARY CONNECTOR-82
PRIMARY TO SECONDARY CONNECTOR-83
PRIMARY TO SECONDARY CONNECTOR-84
PRIMARY TO SECONDARY CONNECTOR-85
PRIMARY TO SECONDARY CONNECTOR-86
PRIMARY TO SECONDARY CONNECTOR-87
PRIMARY TO SECONDARY CONNECTOR-88
PRIMARY TO SECONDARY CONNECTOR-89
PRIMARY TO SECONDARY CONNECTOR-90
PRIMARY TO SECONDARY CONNECTOR-91
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-41
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-42
PRIMARY TO SECONDARY CONNECTOR-92
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-43
PRIMARY TO SECONDARY CONNECTOR-93
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-44
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-45
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-46
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-47
PRIMARY TO SECONDARY CONNECTOR-94
PRIMARY TO SECONDARY CONNECTOR-95
PRIMARY TO SECONDARY CONNECTOR-96
PRIMARY TO SECONDARY CONNECTOR-97
PRIMARY TO SECONDARY CONNECTOR-98
PRIMARY TO SECONDARY CONNECTOR-99
PRIMARY TO SECONDARY CONNECTOR-100
PRIMARY TO SECONDARY CONNECTOR-101
PRIMARY TO SECONDARY CONNECTOR-102
PRIMARY TO SECONDARY CONNECTOR-103
PRIMARY TO SECONDARY CONNECTOR-104
PRIMARY TO SECONDARY CONNECTOR-105
PRIMARY TO SECONDARY CONNECTOR-106
PRIMARY TO SECONDARY CONNECTOR-107
PRIMARY TO SECONDARY CONNECTOR-108
PRIMARY TO SECONDARY CONNECTOR-109
PRIMARY TO SECONDARY CONNECTOR-110
PRIMARY TO SECONDARY CONNECTOR-111
PRIMARY TO SECONDARY CONNECTOR-112
PRIMARY TO SECONDARY CONNECTOR-113
PRIMARY TO SECONDARY CONNECTOR-114
PRIMARY TO SECONDARY CONNECTOR-115
PRIMARY TO SECONDARY CONNECTOR-116
PRIMARY TO SECONDARY CONNECTOR-117
PRIMARY TO SECONDARY CONNECTOR-118
PRIMARY TO SECONDARY CONNECTOR-119
PRIMARY TO SECONDARY CONNECTOR-120
PRIMARY TO SECONDARY CONNECTOR-121
PRIMARY TO SECONDARY CONNECTOR-122
PRIMARY TO SECONDARY CONNECTOR-123
PRIMARY TO SECONDARY CONNECTOR-124
PRIMARY TO SECONDARY CONNECTOR-125
PRIMARY TO SECONDARY CONNECTOR-126
PRIMARY TO SECONDARY CONNECTOR-127
PRIMARY TO SECONDARY CONNECTOR-128
PRIMARY TO SECONDARY CONNECTOR-129
PRIMARY TO SECONDARY CONNECTOR-130
PRIMARY TO SECONDARY CONNECTOR-131
PRIMARY TO SECONDARY CONNECTOR-132
PRIMARY TO SECONDARY CONNECTOR-133
PRIMARY TO SECONDARY CONNECTOR-134
PRIMARY TO SECONDARY CONNECTOR-135
PRIMARY TO SECONDARY CONNECTOR-136
PRIMARY TO SECONDARY CONNECTOR-137
PRIMARY TO SECONDARY CONNECTOR-138
PRIMARY TO SECONDARY CONNECTOR-139
PRIMARY TO SECONDARY CONNECTOR-140
PRIMARY TO SECONDARY CONNECTOR-141
PRIMARY TO SECONDARY CONNECTOR-142
PRIMARY TO SECONDARY CONNECTOR-143
PRIMARY TO SECONDARY CONNECTOR-144
PRIMARY TO SECONDARY CONNECTOR-145
PRIMARY TO SECONDARY CONNECTOR-146
PRIMARY TO SECONDARY CONNECTOR-147
PRIMARY TO SECONDARY CONNECTOR-148
PRIMARY TO SECONDARY CONNECTOR-149
PRIMARY TO SECONDARY CONNECTOR-150
PRIMARY TO SECONDARY CONNECTOR-151
PRIMARY TO SECONDARY CONNECTOR-152
PRIMARY TO SECONDARY CONNECTOR-153
PRIMARY TO SECONDARY CONNECTOR-154
PRIMARY TO SECONDARY CONNECTOR-155
PRIMARY TO SECONDARY CONNECTOR-156
PRIMARY TO SECONDARY CONNECTOR-157
PRIMARY TO SECONDARY CONNECTOR-158
PRIMARY TO SECONDARY CONNECTOR-159
PRIMARY TO SECONDARY CONNECTOR-160
PRIMARY TO SECONDARY CONNECTOR-161
PRIMARY TO SECONDARY CONNECTOR-162
PRIMARY TO SECONDARY CONNECTOR-163
PRIMARY TO SECONDARY CONNECTOR-164
PRIMARY TO SECONDARY CONNECTOR-165
PRIMARY TO SECONDARY CONNECTOR-166
PRIMARY TO SECONDARY CONNECTOR-167
PRIMARY TO SECONDARY CONNECTOR-168
PRIMARY TO SECONDARY CONNECTOR-169
PRIMARY TO SECONDARY CONNECTOR-170
PRIMARY TO SECONDARY CONNECTOR-171
PRIMARY TO SECONDARY CONNECTOR-172
PRIMARY TO SECONDARY CONNECTOR-173
PRIMARY TO SECONDARY CONNECTOR-174
PRIMARY TO SECONDARY CONNECTOR-175
EBL-EKF-S-2424-20-000 FIN - STRAIGHT + ACF SUSRAIL - PRIMARY WIDE ASSEMBLY-48
PRIMARY TO SECONDARY CONNECTOR-176
PRIMARY TO SECONDARY CONNECTOR-177
PRIMARY TO SECONDARY CONNECTOR-178
PRIMARY TO SECONDARY CONNECTOR-179
PRIMARY TO SECONDARY CONNECTOR-180
PRIMARY TO SECONDARY CONNECTOR-181
PRIMARY TO SECONDARY CONNECTOR-182
PRIMARY TO SECONDARY CONNECTOR-183
PRIMARY TO SECONDARY CONNECTOR-184
PRIMARY TO SECONDARY CONNECTOR-185
PRIMARY TO SECONDARY CONNECTOR-186
F000264 P50 SUSPENSION FITTING.SLDPRT-1
PRIMARY TO SECONDARY CONNECTOR-187
PRIMARY TO SECONDARY CONNECTOR-188
PRIMARY TO SECONDARY CONNECTOR-189
PRIMARY TO SECONDARY CONNECTOR-190
PRIMARY TO SECONDARY CONNECTOR-191
PRIMARY TO SECONDARY CONNECTOR-192
PRIMARY TO SECONDARY CONNECTOR-193
PRIMARY TO SECONDARY CONNECTOR-194
PRIMARY TO SECONDARY CONNECTOR-195
F000264 P50 SUSPENSION FITTING.SLDPRT-2
F000264 P50 SUSPENSION FITTING.SLDPRT-3
F000264 P50 SUSPENSION FITTING.SLDPRT-4
F000264 P50 SUSPENSION FITTING.SLDPRT-5
F000264 P50 SUSPENSION FITTING.SLDPRT-6
F000264 P50 SUSPENSION FITTING.SLDPRT-7
F000264 P50 SUSPENSION FITTING.SLDPRT-8
F000264 P50 SUSPENSION FITTING.SLDPRT-9
F000264 P50 SUSPENSION FITTING.SLDPRT-10
F000264 P50 SUSPENSION FITTING.SLDPRT-11
F000264 P50 SUSPENSION FITTING.SLDPRT-12
F000264 P50 SUSPENSION FITTING.SLDPRT-13
F000264 P50 SUSPENSION FITTING.SLDPRT-14
F000264 P50 SUSPENSION FITTING.SLDPRT-15
ACF SUSRAIL - PRIMARY SECONDARY-1
F000264 P50 SUSPENSION FITTING.SLDPRT-16
F000264 P50 SUSPENSION FITTING.SLDPRT-17
F000264 P50 SUSPENSION FITTING.SLDPRT-18
F000264 P50 SUSPENSION FITTING.SLDPRT-19
F000264 P50 SUSPENSION FITTING.SLDPRT-20
F000264 P50 SUSPENSION FITTING.SLDPRT-21
ACF SUSRAIL - PRIMARY SECONDARY-2
ACF SUSRAIL - PRIMARY SECONDARY-3
F000264 P50 SUSPENSION FITTING.SLDPRT-22
F000264 P50 SUSPENSION FITTING.SLDPRT-23
